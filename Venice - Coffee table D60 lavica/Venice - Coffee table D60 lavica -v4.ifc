Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Venice - Coffee table D60 lavica -v4.ifc
Time: 2023-11-09T17:52:11
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (5)
Name
 | Venice - Coffee table D60 lavica_1 - ObjectType: SketchupGroup
 | Venice - Coffee table D60 lavica_0 - ObjectType: SketchupGroup
 | Venice - Coffee table D60 lavica_3 - ObjectType: SketchupGroup
 | Venice - Coffee table D60 lavica_4 - ObjectType: SketchupGroup
 | Venice - Coffee table D60 lavica_2 - ObjectType: SketchupGroup
